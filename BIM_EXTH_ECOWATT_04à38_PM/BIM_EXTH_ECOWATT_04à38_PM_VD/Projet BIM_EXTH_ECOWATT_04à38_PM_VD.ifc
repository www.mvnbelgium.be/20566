Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2021-04-15T09:45:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Interface alternative d'export 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Apr 15 09:45:43 2021 * Host: User-PC * Database: C:\Users\User\AppData\Local\Temp\{B5D9E0F1-708D-486A-A7D4-E6D6D9DFC6F1}\ifc * Database version: 5507 * Database creation date: Thu Apr 15 09:45:42 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Apr 15 09:45:42 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Apr 15 09:45:42 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 52, 0, 117187; RefLongitude: 2, 19, 59, 880409; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no

# IfcFlowMovingDevice: EXTH ECOWATT PM 10 VD IS, BIM_EXTH_ECOWATT_04à38_PM_VD:EXTH ECOWATT PM 10 VD IS:293624
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; 2_poignees: no; 4_poignees: yes; Grille_extraction: 0.1 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_VD; Visibilité_marque: yes
Type - Cotes(Type) - A: 0.804 m; B: 0.603 m; C: 0.448 m; E: 0.777 m; F: 0.544 m; G: 0.194 m; H: 0.161 m; Hauteur_porte: 0.355 m; Hauteur_traverse: 0.101 m; I: 0.166 m; J: 0.198 m; Largeur_porte: 0.245 m; Largeur_traverse: 0.156 m; ØD1: 0.25 m; ØD1_Int: 0.246 m; ØD2: 0.2 m; ØD2_int: 0.196 m; Pos_H_inter: 0.192 m; Pos_V_inter: 0.095 m
Type - Données d'identification(Type) - Code_article: 5400222; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 10 VD IS Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 10 VD IS; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 32 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1.2 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 150 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 1150 m³/h; Debit_mini: 100 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 10 VD IS; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 10 VD IS; ID du type: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 10 VD IS; Type: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 10 VD IS
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0
Cotes - Surface: 2.0811 m2; Volume: 0.130985 m3
Données d'identification - Identifiant: 44
Génie climatique - Classification du système: Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 10 VD NU, BIM_EXTH_ECOWATT_04à38_PM_VD:EXTH ECOWATT PM 10 VD NU:293638
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; 2_poignees: no; 4_poignees: yes; Visibilité_marque: yes; Grille_extraction: 0.1 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_VD
Type - Cotes(Type) - A: 0.804 m; B: 0.603 m; C: 0.421 m; E: 0.777 m; F: 0.544 m; G: 0.194 m; H: 0.161 m; Hauteur_porte: 0.355 m; Hauteur_traverse: 0.101 m; I: 0.166 m; J: 0.198 m; Largeur_porte: 0.245 m; Largeur_traverse: 0.156 m; ØD1: 0.25 m; ØD1_Int: 0.246 m; ØD2: 0.2 m; ØD2_int: 0.196 m; Pos_H_inter: 0.192 m; Pos_V_inter: 0.095 m
Type - Données d'identification(Type) - Code_article: 5400223; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 10 VD Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 10 VD NU; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 32 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1.2 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 150 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 1150 m³/h; Debit_mini: 100 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 10 VD NU; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 10 VD NU; ID du type: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 10 VD NU; Type: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 10 VD NU
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0
Cotes - Surface: 2.04457 m2; Volume: 0.119348 m3
Données d'identification - Identifiant: 45
Génie climatique - Classification du système: Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 22 VD IS, BIM_EXTH_ECOWATT_04à38_PM_VD:EXTH ECOWATT PM 22 VD IS:293652
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; 2_poignees: no; 4_poignees: yes; Visibilité_marque: yes; Grille_extraction: 0.205 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_VD
Type - Cotes(Type) - A: 1.037 m; B: 0.72 m; C: 0.538 m; E: 0.998 m; F: 0.661 m; G: 0.239 m; H: 0.219 m; Hauteur_porte: 0.43 m; Hauteur_traverse: 0.101 m; I: 0.236 m; J: 0.271 m; Largeur_porte: 0.245 m; Largeur_traverse: 0.156 m; ØD1: 0.355 m; ØD1_Int: 0.351 m; ØD2: 0.315 m; ØD2_int: 0.311 m; Pos_H_inter: 0.192 m; Pos_V_inter: 0.115 m
Type - Données d'identification(Type) - Code_article: 5400234; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 22 VD IS Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 22 VD IS; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 55 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1.6 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 350 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 2200 m³/h; Debit_mini: 100 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 22 VD IS; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 22 VD IS; ID du type: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 22 VD IS; Type: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 22 VD IS
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 3.0201 m2; Volume: 0.265784 m3
Données d'identification - Identifiant: 46
Génie climatique - Classification du système: Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 22 VD Nu, BIM_EXTH_ECOWATT_04à38_PM_VD:EXTH ECOWATT PM 22 VD Nu:293666
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; 2_poignees: no; 4_poignees: yes; Visibilité_marque: yes; Grille_extraction: 0.205 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_VD
Type - Cotes(Type) - A: 1.037 m; B: 0.72 m; C: 0.511 m; E: 0.998 m; F: 0.661 m; G: 0.239 m; H: 0.219 m; Hauteur_porte: 0.43 m; Hauteur_traverse: 0.101 m; I: 0.236 m; J: 0.271 m; Largeur_porte: 0.245 m; Largeur_traverse: 0.156 m; ØD1: 0.355 m; ØD1_Int: 0.351 m; ØD2: 0.315 m; ØD2_int: 0.311 m; Pos_H_inter: 0.192 m; Pos_V_inter: 0.115 m
Type - Données d'identification(Type) - Code_article: 5400235; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 22 VD Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 22 VD Nu; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 45 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1.6 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 350 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 2200 m³/h; Debit_mini: 100 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 22 VD Nu; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 22 VD Nu; ID du type: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 22 VD Nu; Type: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 22 VD Nu
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 2.97412 m2; Volume: 0.24748 m3
Données d'identification - Identifiant: 47
Génie climatique - Classification du système: Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 38 VD IS, BIM_EXTH_ECOWATT_04à38_PM_VD:EXTH ECOWATT PM 38 VD IS:293680
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; 2_poignees: no; 4_poignees: yes; Visibilité_marque: yes; Grille_extraction: 0.35 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_VD
Type - Cotes(Type) - A: 1.422 m; B: 1.023 m; C: 0.666 m; E: 1.382 m; F: 0.894 m; G: 0.315 m; H: 0.273 m; Hauteur_porte: 0.562 m; Hauteur_traverse: 0.101 m; I: 0.27 m; J: 0.345 m; Largeur_porte: 0.648 m; Largeur_traverse: 0.156 m; ØD1: 0.5 m; ØD1_Int: 0.496 m; ØD2: 0.4 m; ØD2_int: 0.396 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410266; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 38 VD IS Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 38 VD IS; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 94 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 3.1 A; Nombre_de_phases: 1; Protection_IP: IP54; Puissance_electrique: 700 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 4200 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 38 VD IS; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 38 VD IS; ID du type: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 38 VD IS; Type: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 38 VD IS
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 5.51774 m2; Volume: 0.703585 m3
Données d'identification - Identifiant: 48
Génie climatique - Classification du système: Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 38 VD IS Tri, BIM_EXTH_ECOWATT_04à38_PM_VD:EXTH ECOWATT PM 38 VD IS Tri:293694
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; 2_poignees: no; 4_poignees: yes; Visibilité_marque: yes; Grille_extraction: 0.35 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_VD
Type - Cotes(Type) - A: 1.422 m; B: 1.023 m; C: 0.666 m; E: 1.382 m; F: 0.894 m; G: 0.315 m; H: 0.273 m; Hauteur_porte: 0.562 m; Hauteur_traverse: 0.101 m; I: 0.27 m; J: 0.345 m; Largeur_porte: 0.648 m; Largeur_traverse: 0.156 m; ØD1: 0.5 m; ØD1_Int: 0.496 m; ØD2: 0.4 m; ØD2_int: 0.396 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410267; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 38 VD IS Tri RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 38 VD IS Tri; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 94 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 1.3 A; Nombre_de_phases: 3; Protection_IP: IP54; Puissance_electrique: 700 W; Tension_nominale: 37.1612 V
Type - Génie climatique(Type) - Debit_maxi: 4200 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 38 VD IS Tri; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 38 VD IS Tri; ID du type: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 38 VD IS Tri; Type: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 38 VD IS Tri
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 5.51774 m2; Volume: 0.703585 m3
Données d'identification - Identifiant: 49
Génie climatique - Classification du système: Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 38 VD NU, BIM_EXTH_ECOWATT_04à38_PM_VD:EXTH ECOWATT PM 38 VD NU:293708
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; 2_poignees: no; 4_poignees: yes; Visibilité_marque: yes; Grille_extraction: 0.35 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_VD
Type - Cotes(Type) - A: 1.422 m; B: 1.023 m; C: 0.639 m; E: 1.382 m; F: 0.894 m; G: 0.315 m; H: 0.273 m; Hauteur_porte: 0.562 m; Hauteur_traverse: 0.101 m; I: 0.27 m; J: 0.345 m; Largeur_porte: 0.648 m; Largeur_traverse: 0.156 m; ØD1: 0.5 m; ØD1_Int: 0.496 m; ØD2: 0.4 m; ØD2_int: 0.396 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410268; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 38 VD Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 38 VD NU; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 83 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 3.1 A; Nombre_de_phases: 1; Protection_IP: IP54; Puissance_electrique: 700 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 4200 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 38 VD NU; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 38 VD NU; ID du type: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 38 VD NU; Type: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 38 VD NU
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 5.45318 m2; Volume: 0.666937 m3
Données d'identification - Identifiant: 50
Génie climatique - Classification du système: Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 38 VD NU Tri, BIM_EXTH_ECOWATT_04à38_PM_VD:EXTH ECOWATT PM 38 VD NU Tri:293722
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; 2_poignees: no; 4_poignees: yes; Visibilité_marque: yes; Grille_extraction: 0.35 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_VD
Type - Cotes(Type) - A: 1.422 m; B: 1.023 m; C: 0.639 m; E: 1.382 m; F: 0.894 m; G: 0.315 m; H: 0.273 m; Hauteur_porte: 0.562 m; Hauteur_traverse: 0.101 m; I: 0.27 m; J: 0.345 m; Largeur_porte: 0.648 m; Largeur_traverse: 0.156 m; ØD1: 0.5 m; ØD1_Int: 0.496 m; ØD2: 0.4 m; ØD2_int: 0.396 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410269; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 38 VD Tri RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 38 VD NU Tri; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 83 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 1.3 A; Nombre_de_phases: 3; Protection_IP: IP54; Puissance_electrique: 700 W; Tension_nominale: 37.1612 V
Type - Génie climatique(Type) - Debit_maxi: 4200 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 38 VD NU Tri; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 38 VD NU Tri; ID du type: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 38 VD NU Tri; Type: BIM_EXTH_ECOWATT_04à38_PM_VD: EXTH ECOWATT PM 38 VD NU Tri
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 5.45318 m2; Volume: 0.666937 m3
Données d'identification - Identifiant: 51
Génie climatique - Classification du système: Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction
