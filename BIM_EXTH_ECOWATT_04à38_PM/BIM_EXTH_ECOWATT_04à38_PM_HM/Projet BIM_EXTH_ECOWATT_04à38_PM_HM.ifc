Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2021-04-15T09:32:32
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Interface alternative d'export 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Apr 15 09:32:32 2021 * Host: User-PC * Database: C:\Users\User\AppData\Local\Temp\{6D850B86-FBD9-4CBC-A58E-AAE1F535C831}\ifc * Database version: 5507 * Database creation date: Thu Apr 15 09:32:29 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Apr 15 09:32:29 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Apr 15 09:32:29 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 52, 0, 117187; RefLongitude: 2, 19, 59, 880409; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no

# IfcFlowMovingDevice: EXTH ECOWATT PM 04 HM IS, BIM_EXTH_ECOWATT_04à38_PM_HM:EXTH ECOWATT PM 04 HM IS:293629
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HM; Visibilité_marque: yes
Type - Cotes(Type) - A: 0.627 m; B: 0.523 m; B': 0.533 m; C: 0.347 m; E: 0.568 m; F: 0.502 m; G: 0.157 m; H: 0.175 m; Hauteur_porte: 0.255 m; I: 0.157 m; J: 0.161 m; Largeur_porte: 0.439 m; ØD1: 0.16 m; ØD1_Int: 0.156 m; Pos_H_inter: 0.413 m; Pos_V_inter: 0.097 m
Type - Données d'identification(Type) - Code_article: 5400202; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 04 HM IS Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 04 HM IS; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 24 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 0.7 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 70 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 480 m³/h; Debit_mini: 20 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 04 HM IS; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 04 HM IS; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 04 HM IS; Type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 04 HM IS
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0
Cotes - Surface: 1.08232 m2; Volume: 0.0852858 m3
Données d'identification - Identifiant: 44
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance,Reprise; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 04 HM NU, BIM_EXTH_ECOWATT_04à38_PM_HM:EXTH ECOWATT PM 04 HM NU:293643
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HM
Type - Cotes(Type) - A: 0.627 m; B: 0.523 m; B': 0.533 m; C: 0.32 m; E: 0.568 m; F: 0.502 m; G: 0.157 m; H: 0.175 m; Hauteur_porte: 0.255 m; I: 0.157 m; J: 0.161 m; Largeur_porte: 0.439 m; ØD1: 0.16 m; ØD1_Int: 0.156 m; Pos_H_inter: 0.413 m; Pos_V_inter: 0.097 m
Type - Données d'identification(Type) - Code_article: 5400203; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 04 HM Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 04 HM NU; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 21 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 0.7 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 70 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 480 m³/h; Debit_mini: 20 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 04 HM NU; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 04 HM NU; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 04 HM NU; Type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 04 HM NU
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.05499 m2; Volume: 0.0783988 m3
Données d'identification - Identifiant: 45
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance,Reprise; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 06 HM IS, BIM_EXTH_ECOWATT_04à38_PM_HM:EXTH ECOWATT PM 06 HM IS:293657
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HM
Type - Cotes(Type) - A: 0.627 m; B: 0.523 m; B': 0.533 m; C: 0.347 m; E: 0.568 m; F: 0.502 m; G: 0.157 m; H: 0.175 m; Hauteur_porte: 0.255 m; I: 0.157 m; J: 0.161 m; Largeur_porte: 0.439 m; ØD1: 0.2 m; ØD1_Int: 0.196 m; Pos_H_inter: 0.413 m; Pos_V_inter: 0.097 m
Type - Données d'identification(Type) - Code_article: 5400210; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 06 HM IS Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 06 HM IS; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 24 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 130 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 660 m³/h; Debit_mini: 70 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 06 HM IS; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 06 HM IS; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 06 HM IS; Type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 06 HM IS
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.09865 m2; Volume: 0.085317 m3
Données d'identification - Identifiant: 46
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance,Reprise; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 06 HM NU, BIM_EXTH_ECOWATT_04à38_PM_HM:EXTH ECOWATT PM 06 HM NU:293671
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HM
Type - Cotes(Type) - A: 0.627 m; B: 0.523 m; B': 0.533 m; C: 0.32 m; E: 0.568 m; F: 0.502 m; G: 0.157 m; H: 0.175 m; Hauteur_porte: 0.255 m; I: 0.157 m; J: 0.161 m; Largeur_porte: 0.439 m; ØD1: 0.2 m; ØD1_Int: 0.196 m; Pos_H_inter: 0.413 m; Pos_V_inter: 0.097 m
Type - Données d'identification(Type) - Code_article: 5400211; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 06 HM Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 06 HM NU; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 21 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 130 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 660 m³/h; Debit_mini: 70 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 06 HM NU; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 06 HM NU; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 06 HM NU; Type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 06 HM NU
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.07133 m2; Volume: 0.07843 m3
Données d'identification - Identifiant: 47
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance,Reprise; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 10 HM IS, BIM_EXTH_ECOWATT_04à38_PM_HM:EXTH ECOWATT PM 10 HM IS:293685
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HM
Type - Cotes(Type) - A: 0.627 m; B: 0.566 m; B': 0.583 m; C: 0.448 m; E: 0.569 m; F: 0.544 m; G: 0.207 m; H: 0.185 m; Hauteur_porte: 0.355 m; I: 0.207 m; J: 0.186 m; Largeur_porte: 0.245 m; ØD1: 0.25 m; ØD1_Int: 0.246 m; Pos_H_inter: 0.192 m; Pos_V_inter: 0.095 m
Type - Données d'identification(Type) - Code_article: 5400220; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 10 HM IS Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 10 HM IS; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 30 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1.2 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 150 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 1150 m³/h; Debit_mini: 100 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 10 HM IS; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 10 HM IS; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 10 HM IS; Type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 10 HM IS
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0
Cotes - Surface: 1.26529 m2; Volume: 0.121487 m3
Données d'identification - Identifiant: 48
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance,Reprise; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 10 HM NU, BIM_EXTH_ECOWATT_04à38_PM_HM:EXTH ECOWATT PM 10 HM NU:293699
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HM
Type - Cotes(Type) - A: 0.627 m; B: 0.566 m; B': 0.583 m; C: 0.421 m; E: 0.569 m; F: 0.544 m; G: 0.207 m; H: 0.185 m; Hauteur_porte: 0.355 m; I: 0.207 m; J: 0.186 m; Largeur_porte: 0.245 m; ØD1: 0.25 m; ØD1_Int: 0.246 m; Pos_H_inter: 0.192 m; Pos_V_inter: 0.095 m
Type - Données d'identification(Type) - Code_article: 5400221; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 10 HM Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 10 HM NU; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 26 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1.2 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 150 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 1150 m³/h; Debit_mini: 100 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 10 HM NU; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 10 HM NU; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 10 HM NU; Type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 10 HM NU
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.2368 m2; Volume: 0.113976 m3
Données d'identification - Identifiant: 49
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance,Reprise; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 22 HM IS, BIM_EXTH_ECOWATT_04à38_PM_HM:EXTH ECOWATT PM 22 HM IS:293713
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HM
Type - Cotes(Type) - A: 0.767 m; B: 0.683 m; B': 0.701 m; C: 0.538 m; E: 0.709 m; F: 0.661 m; G: 0.252 m; H: 0.237 m; Hauteur_porte: 0.43 m; I: 0.252 m; J: 0.239 m; Largeur_porte: 0.245 m; ØD1: 0.355 m; ØD1_Int: 0.351 m; Pos_H_inter: 0.192 m; Pos_V_inter: 0.115 m
Type - Données d'identification(Type) - Code_article: 5400232; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 22 HM IS Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 22 HM IS; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 45 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1.6 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 350 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 2200 m³/h; Debit_mini: 100 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 22 HM IS; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 22 HM IS; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 22 HM IS; Type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 22 HM IS
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.86721 m2; Volume: 0.226589 m3
Données d'identification - Identifiant: 50
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance,Reprise; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 22 HM NU, BIM_EXTH_ECOWATT_04à38_PM_HM:EXTH ECOWATT PM 22 HM NU:293731
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HM
Type - Cotes(Type) - A: 0.767 m; B: 0.683 m; B': 0.701 m; C: 0.511 m; E: 0.709 m; F: 0.661 m; G: 0.252 m; H: 0.237 m; Hauteur_porte: 0.43 m; I: 0.252 m; J: 0.239 m; Largeur_porte: 0.245 m; ØD1: 0.355 m; ØD1_Int: 0.351 m; Pos_H_inter: 0.192 m; Pos_V_inter: 0.115 m
Type - Données d'identification(Type) - Code_article: 5400233; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 22 HM Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 22 HM NU; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 38 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1.6 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 350 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 2200 m³/h; Debit_mini: 100 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 22 HM NU; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 22 HM NU; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 22 HM NU; Type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 22 HM NU
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.83179 m2; Volume: 0.214982 m3
Données d'identification - Identifiant: 51
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance,Reprise; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 30 HM IS, BIM_EXTH_ECOWATT_04à38_PM_HM:EXTH ECOWATT PM 30 HM IS:293745
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HM
Type - Cotes(Type) - A: 1.018 m; B: 0.824 m; B': 0.874 m; C: 0.6 m; E: 0.89 m; F: 0.796 m; G: 0.28 m; H: 0.273 m; Hauteur_porte: 0.497 m; I: 0.28 m; J: 0.273 m; Largeur_porte: 0.648 m; ØD1: 0.4 m; ØD1_Int: 0.396 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410243; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 30 HM IS Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 30 HM IS; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 73 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 2.6 A; Nombre_de_phases: 1; Protection_IP: IP54; Puissance_electrique: 600 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 3200 m³/h; Debit_mini: 200 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 30 HM IS; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 30 HM IS; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 30 HM IS; Type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 30 HM IS
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 3.04564 m2; Volume: 0.422652 m3
Données d'identification - Identifiant: 52
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance,Reprise; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 30 HM IS Tri, BIM_EXTH_ECOWATT_04à38_PM_HM:EXTH ECOWATT PM 30 HM IS Tri:293759
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HM
Type - Cotes(Type) - A: 1.018 m; B: 0.824 m; B': 0.874 m; C: 0.6 m; E: 0.89 m; F: 0.796 m; G: 0.28 m; H: 0.273 m; Hauteur_porte: 0.497 m; I: 0.28 m; J: 0.273 m; Largeur_porte: 0.648 m; ØD1: 0.4 m; ØD1_Int: 0.396 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410244; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 30 HM IS Tri RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 30 HM IS Tri; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 73 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 1.2 A; Nombre_de_phases: 3; Protection_IP: IP54; Puissance_electrique: 600 W; Tension_nominale: 37.1612 V
Type - Génie climatique(Type) - Debit_maxi: 3200 m³/h; Debit_mini: 200 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 30 HM IS Tri; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 30 HM IS Tri; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 30 HM IS Tri; Type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 30 HM IS Tri
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 3.04564 m2; Volume: 0.422652 m3
Données d'identification - Identifiant: 53
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance,Reprise; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 30 HM NU, BIM_EXTH_ECOWATT_04à38_PM_HM:EXTH ECOWATT PM 30 HM NU:293773
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HM
Type - Cotes(Type) - A: 1.018 m; B: 0.824 m; B': 0.874 m; C: 0.574 m; E: 0.89 m; F: 0.796 m; G: 0.28 m; H: 0.273 m; Hauteur_porte: 0.497 m; I: 0.28 m; J: 0.273 m; Largeur_porte: 0.648 m; ØD1: 0.4 m; ØD1_Int: 0.396 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410245; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 30 HM Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 30 HM NU; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 64 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 2.6 A; Nombre_de_phases: 1; Protection_IP: IP54; Puissance_electrique: 600 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 3200 m³/h; Debit_mini: 200 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 30 HM NU; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 30 HM NU; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 30 HM NU; Type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 30 HM NU
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 3.00133 m2; Volume: 0.403929 m3
Données d'identification - Identifiant: 54
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance,Reprise; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 30 HM NU Tri, BIM_EXTH_ECOWATT_04à38_PM_HM:EXTH ECOWATT PM 30 HM NU Tri:293787
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HM
Type - Cotes(Type) - A: 1.018 m; B: 0.824 m; B': 0.874 m; C: 0.574 m; E: 0.89 m; F: 0.796 m; G: 0.28 m; H: 0.273 m; Hauteur_porte: 0.497 m; I: 0.28 m; J: 0.273 m; Largeur_porte: 0.648 m; ØD1: 0.4 m; ØD1_Int: 0.396 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410246; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 30 HM Tri RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 30 HM NU Tri; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 64 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 1.2 A; Nombre_de_phases: 3; Protection_IP: IP54; Puissance_electrique: 600 W; Tension_nominale: 37.1612 V
Type - Génie climatique(Type) - Debit_maxi: 3200 m³/h; Debit_mini: 200 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 30 HM NU Tri; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 30 HM NU Tri; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 30 HM NU Tri; Type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 30 HM NU Tri
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 3.00133 m2; Volume: 0.403929 m3
Données d'identification - Identifiant: 55
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance,Reprise; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 38 HM IS, BIM_EXTH_ECOWATT_04à38_PM_HM:EXTH ECOWATT PM 38 HM IS:293805
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HM
Type - Cotes(Type) - A: 1.152 m; B: 0.923 m; B': 0.973 m; C: 0.666 m; E: 1.022 m; F: 0.894 m; G: 0.315 m; H: 0.323 m; Hauteur_porte: 0.562 m; I: 0.315 m; J: 0.323 m; Largeur_porte: 0.648 m; ØD1: 0.5 m; ØD1_Int: 0.496 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410262; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 38 HM IS Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 38 HM IS; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 88 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 3.1 A; Nombre_de_phases: 1; Protection_IP: IP54; Puissance_electrique: 700 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 4200 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 38 HM IS; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 38 HM IS; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 38 HM IS; Type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 38 HM IS
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 3.82757 m2; Volume: 0.607111 m3
Données d'identification - Identifiant: 56
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance,Reprise; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 38 HM IS Tri, BIM_EXTH_ECOWATT_04à38_PM_HM:EXTH ECOWATT PM 38 HM IS Tri:293819
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HM
Type - Cotes(Type) - A: 1.152 m; B: 0.923 m; B': 0.973 m; C: 0.666 m; E: 1.022 m; F: 0.894 m; G: 0.315 m; H: 0.323 m; Hauteur_porte: 0.562 m; I: 0.315 m; J: 0.323 m; Largeur_porte: 0.648 m; ØD1: 0.5 m; ØD1_Int: 0.496 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410263; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 38 HM IS Tri RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 38 HM IS Tri; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 88 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 1.3 A; Nombre_de_phases: 3; Protection_IP: IP54; Puissance_electrique: 700 W; Tension_nominale: 37.1612 V
Type - Génie climatique(Type) - Debit_maxi: 4200 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 38 HM IS Tri; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 38 HM IS Tri; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 38 HM IS Tri; Type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 38 HM IS Tri
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 3.82757 m2; Volume: 0.607111 m3
Données d'identification - Identifiant: 57
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance,Reprise; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 38 HM NU, BIM_EXTH_ECOWATT_04à38_PM_HM:EXTH ECOWATT PM 38 HM NU:293833
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HM
Type - Cotes(Type) - A: 1.152 m; B: 0.923 m; B': 0.973 m; C: 0.639 m; E: 1.022 m; F: 0.894 m; G: 0.315 m; H: 0.323 m; Hauteur_porte: 0.562 m; I: 0.315 m; J: 0.323 m; Largeur_porte: 0.648 m; ØD1: 0.5 m; ØD1_Int: 0.496 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410264; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 38 HM Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 38 HM NU; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 78 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 3.1 A; Nombre_de_phases: 1; Protection_IP: IP54; Puissance_electrique: 700 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 4200 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 38 HM NU; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 38 HM NU; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 38 HM NU; Type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 38 HM NU
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 3.77527 m2; Volume: 0.582021 m3
Données d'identification - Identifiant: 58
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance,Reprise; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 38 HM NU Tri, BIM_EXTH_ECOWATT_04à38_PM_HM:EXTH ECOWATT PM 38 HM NU Tri:293847
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HM
Type - Cotes(Type) - A: 1.152 m; B: 0.923 m; B': 0.973 m; C: 0.639 m; E: 1.022 m; F: 0.894 m; G: 0.315 m; H: 0.323 m; Hauteur_porte: 0.562 m; I: 0.315 m; J: 0.323 m; Largeur_porte: 0.648 m; ØD1: 0.5 m; ØD1_Int: 0.496 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410265; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 38 HM Tri RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 38 HM NU Tri; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 78 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 1.3 A; Nombre_de_phases: 3; Protection_IP: IP54; Puissance_electrique: 700 W; Tension_nominale: 37.1612 V
Type - Génie climatique(Type) - Debit_maxi: 4200 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 38 HM NU Tri; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 38 HM NU Tri; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 38 HM NU Tri; Type: BIM_EXTH_ECOWATT_04à38_PM_HM: EXTH ECOWATT PM 38 HM NU Tri
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 3.77527 m2; Volume: 0.582021 m3
Données d'identification - Identifiant: 59
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance,Reprise; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction
