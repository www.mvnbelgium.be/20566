Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2021-04-15T09:36:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Interface alternative d'export 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Apr 15 09:36:56 2021 * Host: User-PC * Database: C:\Users\User\AppData\Local\Temp\{4F92BE09-DD93-45AC-930E-250AD2A642CA}\ifc * Database version: 5507 * Database creation date: Thu Apr 15 09:36:53 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Apr 15 09:36:53 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Apr 15 09:36:53 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 52, 0, 117187; RefLongitude: 2, 19, 59, 880409; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no

# IfcFlowMovingDevice: EXTH ECOWATT PM 04 VL IS, BIM_EXTH_ECOWATT_04à38_PM_VL:EXTH ECOWATT PM 04 VL IS:293552
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Grille_extraction: 0.1 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_VL; Visibilité_marque: yes
Type - Cotes(Type) - A: 0.609 m; B: 0.523 m; C: 0.347 m; E: 0.568 m; F: 0.502 m; G: 0.157 m; H: 0.175 m; Hauteur_porte: 0.255 m; I: 0.13 m; J: 0.165 m; Largeur_porte: 0.439 m; ØD1: 0.16 m; ØD1_Int: 0.156 m; Pos_H_inter: 0.413 m; Pos_V_inter: 0.097 m
Type - Données d'identification(Type) - Code_article: 263020; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 04 VL IS Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 04 VL IS; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 24 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 0.7 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 70 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 480 m³/h; Debit_mini: 20 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 04 VL IS; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 04 VL IS; ID du type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 04 VL IS; Type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 04 VL IS
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0
Cotes - Surface: 1.02537 m2; Volume: 0.0722404 m3
Données d'identification - Identifiant: 44
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 04 VL NU, BIM_EXTH_ECOWATT_04à38_PM_VL:EXTH ECOWATT PM 04 VL NU:293564
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.1 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_VL
Type - Cotes(Type) - A: 0.609 m; B: 0.523 m; C: 0.32 m; E: 0.568 m; F: 0.502 m; G: 0.157 m; H: 0.175 m; Hauteur_porte: 0.255 m; I: 0.13 m; J: 0.165 m; Largeur_porte: 0.439 m; ØD1: 0.16 m; ØD1_Int: 0.156 m; Pos_H_inter: 0.413 m; Pos_V_inter: 0.097 m
Type - Données d'identification(Type) - Code_article: 263020; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 04 VL Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 04 VL NU; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 21 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 0.7 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 70 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 480 m³/h; Debit_mini: 20 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 04 VL NU; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 04 VL NU; ID du type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 04 VL NU; Type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 04 VL NU
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0
Cotes - Surface: 0.99853 m2; Volume: 0.0655842 m3
Données d'identification - Identifiant: 45
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 06 VL IS, BIM_EXTH_ECOWATT_04à38_PM_VL:EXTH ECOWATT PM 06 VL IS:293576
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.14 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_VL
Type - Cotes(Type) - A: 0.609 m; B: 0.523 m; C: 0.347 m; E: 0.568 m; F: 0.502 m; G: 0.157 m; H: 0.175 m; Hauteur_porte: 0.255 m; I: 0.13 m; J: 0.165 m; Largeur_porte: 0.439 m; ØD1: 0.2 m; ØD1_Int: 0.196 m; Pos_H_inter: 0.413 m; Pos_V_inter: 0.097 m
Type - Données d'identification(Type) - Code_article: 263020; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 06 VL IS Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 06 VL IS; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 24 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 130 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 660 m³/h; Debit_mini: 70 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 06 VL IS; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 06 VL IS; ID du type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 06 VL IS; Type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 06 VL IS
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.03404 m2; Volume: 0.0722568 m3
Données d'identification - Identifiant: 46
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 06 VL NU, BIM_EXTH_ECOWATT_04à38_PM_VL:EXTH ECOWATT PM 06 VL NU:293588
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.14 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_VL
Type - Cotes(Type) - A: 0.609 m; B: 0.523 m; C: 0.32 m; E: 0.568 m; F: 0.502 m; G: 0.157 m; H: 0.175 m; Hauteur_porte: 0.255 m; I: 0.13 m; J: 0.165 m; Largeur_porte: 0.439 m; ØD1: 0.2 m; ØD1_Int: 0.196 m; Pos_H_inter: 0.413 m; Pos_V_inter: 0.097 m
Type - Données d'identification(Type) - Code_article: 263020; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 06 VL Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 06 VL NU; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 21 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 130 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 660 m³/h; Debit_mini: 70 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 06 VL NU; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 06 VL NU; ID du type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 06 VL NU; Type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 06 VL NU
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.0072 m2; Volume: 0.0656006 m3
Données d'identification - Identifiant: 47
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 10 VL IS, BIM_EXTH_ECOWATT_04à38_PM_VL:EXTH ECOWATT PM 10 VL IS:293600
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.19 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_VL
Type - Cotes(Type) - A: 0.616 m; B: 0.566 m; C: 0.448 m; E: 0.569 m; F: 0.544 m; G: 0.207 m; H: 0.185 m; Hauteur_porte: 0.355 m; I: 0.166 m; J: 0.198 m; Largeur_porte: 0.245 m; ØD1: 0.25 m; ØD1_Int: 0.246 m; Pos_H_inter: 0.192 m; Pos_V_inter: 0.095 m
Type - Données d'identification(Type) - Code_article: 263020; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 10 VL IS Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 10 VL IS; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 30 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1.2 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 150 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 1150 m³/h; Debit_mini: 100 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 10 VL IS; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 10 VL IS; ID du type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 10 VL IS; Type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 10 VL IS
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.19466 m2; Volume: 0.10772 m3
Données d'identification - Identifiant: 48
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 10 VL NU, BIM_EXTH_ECOWATT_04à38_PM_VL:EXTH ECOWATT PM 10 VL NU:293612
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.19 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_VL
Type - Cotes(Type) - A: 0.616 m; B: 0.566 m; C: 0.421 m; E: 0.569 m; F: 0.544 m; G: 0.207 m; H: 0.185 m; Hauteur_porte: 0.355 m; I: 0.166 m; J: 0.198 m; Largeur_porte: 0.245 m; ØD1: 0.25 m; ØD1_Int: 0.246 m; Pos_H_inter: 0.192 m; Pos_V_inter: 0.095 m
Type - Données d'identification(Type) - Code_article: 263020; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PR 10 VL Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 10 VL NU; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 26 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1.2 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 150 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 1150 m³/h; Debit_mini: 100 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 10 VL NU; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 10 VL NU; ID du type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 10 VL NU; Type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 10 VL NU
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.16647 m2; Volume: 0.100363 m3
Données d'identification - Identifiant: 49
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 22 VL IS, BIM_EXTH_ECOWATT_04à38_PM_VL:EXTH ECOWATT PM 22 VL IS:293624
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.295 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_VL
Type - Cotes(Type) - A: 0.756 m; B: 0.683 m; C: 0.538 m; E: 0.709 m; F: 0.661 m; G: 0.252 m; H: 0.237 m; Hauteur_porte: 0.43 m; I: 0.236 m; J: 0.271 m; Largeur_porte: 0.245 m; ØD1: 0.355 m; ØD1_Int: 0.351 m; Pos_H_inter: 0.192 m; Pos_V_inter: 0.115 m
Type - Données d'identification(Type) - Code_article: 263020; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 22 VL IS Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 22 VL IS; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 45 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1.6 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 350 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 2200 m³/h; Debit_mini: 100 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 22 VL IS; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 22 VL IS; ID du type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 22 VL IS; Type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 22 VL IS
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.76974 m2; Volume: 0.205417 m3
Données d'identification - Identifiant: 50
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 22 VL NU, BIM_EXTH_ECOWATT_04à38_PM_VL:EXTH ECOWATT PM 22 VL NU:293640
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.295 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_VL
Type - Cotes(Type) - A: 0.756 m; B: 0.683 m; C: 0.511 m; E: 0.709 m; F: 0.661 m; G: 0.252 m; H: 0.237 m; Hauteur_porte: 0.43 m; I: 0.236 m; J: 0.271 m; Largeur_porte: 0.245 m; ØD1: 0.355 m; ØD1_Int: 0.351 m; Pos_H_inter: 0.192 m; Pos_V_inter: 0.115 m
Type - Données d'identification(Type) - Code_article: 263020; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 22 VL Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 22 VL NU; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 38 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1.6 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 350 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 2200 m³/h; Debit_mini: 100 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 22 VL NU; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 22 VL NU; ID du type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 22 VL NU; Type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 22 VL NU
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.73461 m2; Volume: 0.193998 m3
Données d'identification - Identifiant: 51
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 30 VL IS, BIM_EXTH_ECOWATT_04à38_PM_VL:EXTH ECOWATT PM 30 VL IS:293652
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.34 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_VL
Type - Cotes(Type) - A: 0.972 m; B: 0.824 m; C: 0.6 m; E: 0.89 m; F: 0.796 m; G: 0.28 m; H: 0.273 m; Hauteur_porte: 0.497 m; I: 0.243 m; J: 0.314 m; Largeur_porte: 0.648 m; ØD1: 0.4 m; ØD1_Int: 0.396 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 263020; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 30 VL IS Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 30 VL IS; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 73 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 2.6 A; Nombre_de_phases: 1; Protection_IP: IP54; Puissance_electrique: 600 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 3200 m³/h; Debit_mini: 200 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 30 VL IS; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 30 VL IS; ID du type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 30 VL IS; Type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 30 VL IS
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 2.81555 m2; Volume: 0.373284 m3
Données d'identification - Identifiant: 52
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 30 VL IS Tri, BIM_EXTH_ECOWATT_04à38_PM_VL:EXTH ECOWATT PM 30 VL IS Tri:293668
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.34 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_VL
Type - Cotes(Type) - A: 0.972 m; B: 0.824 m; C: 0.6 m; E: 0.89 m; F: 0.796 m; G: 0.28 m; H: 0.273 m; Hauteur_porte: 0.497 m; I: 0.243 m; J: 0.314 m; Largeur_porte: 0.648 m; ØD1: 0.4 m; ØD1_Int: 0.396 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 263020; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 30 VL IS Tri RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 30 VL IS Tri; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 73 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 1.2 A; Nombre_de_phases: 3; Protection_IP: IP54; Puissance_electrique: 600 W; Tension_nominale: 37.1612 V
Type - Génie climatique(Type) - Debit_maxi: 3200 m³/h; Debit_mini: 200 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 30 VL IS Tri; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 30 VL IS Tri; ID du type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 30 VL IS Tri; Type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 30 VL IS Tri
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 2.81555 m2; Volume: 0.373284 m3
Données d'identification - Identifiant: 53
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 30 VL NU, BIM_EXTH_ECOWATT_04à38_PM_VL:EXTH ECOWATT PM 30 VL NU:293680
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.34 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_VL
Type - Cotes(Type) - A: 0.972 m; B: 0.824 m; C: 0.574 m; E: 0.89 m; F: 0.796 m; G: 0.28 m; H: 0.273 m; Hauteur_porte: 0.497 m; I: 0.243 m; J: 0.314 m; Largeur_porte: 0.648 m; ØD1: 0.4 m; ØD1_Int: 0.396 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 263020; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 30 VL Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 30 VL NU; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 64 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 2.6 A; Nombre_de_phases: 1; Protection_IP: IP54; Puissance_electrique: 600 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 3200 m³/h; Debit_mini: 200 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 30 VL NU; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 30 VL NU; ID du type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 30 VL NU; Type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 30 VL NU
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 2.77245 m2; Volume: 0.355489 m3
Données d'identification - Identifiant: 54
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 30 VL NU Tri, BIM_EXTH_ECOWATT_04à38_PM_VL:EXTH ECOWATT PM 30 VL NU Tri:293692
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.34 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_VL
Type - Cotes(Type) - A: 0.972 m; B: 0.824 m; C: 0.574 m; E: 0.89 m; F: 0.796 m; G: 0.28 m; H: 0.273 m; Hauteur_porte: 0.497 m; I: 0.243 m; J: 0.314 m; Largeur_porte: 0.648 m; ØD1: 0.4 m; ØD1_Int: 0.396 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 263020; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 30 VL Tri RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 30 VL NU Tri; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 64 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 1.2 A; Nombre_de_phases: 3; Protection_IP: IP54; Puissance_electrique: 600 W; Tension_nominale: 37.1612 V
Type - Génie climatique(Type) - Debit_maxi: 3200 m³/h; Debit_mini: 200 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 30 VL NU Tri; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 30 VL NU Tri; ID du type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 30 VL NU Tri; Type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 30 VL NU Tri
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 2.77245 m2; Volume: 0.355489 m3
Données d'identification - Identifiant: 55
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 38 VL IS, BIM_EXTH_ECOWATT_04à38_PM_VL:EXTH ECOWATT PM 38 VL IS:293708
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.44 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_VL
Type - Cotes(Type) - A: 1.106 m; B: 0.923 m; C: 0.666 m; E: 1.022 m; F: 0.894 m; G: 0.315 m; H: 0.323 m; Hauteur_porte: 0.562 m; I: 0.27 m; J: 0.345 m; Largeur_porte: 0.648 m; ØD1: 0.5 m; ØD1_Int: 0.496 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 263020; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 38 VL IS Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 38 VL IS; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 88 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 3.1 A; Nombre_de_phases: 1; Protection_IP: IP54; Puissance_electrique: 700 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 4200 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 38 VL IS; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 38 VL IS; ID du type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 38 VL IS; Type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 38 VL IS
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 3.55384 m2; Volume: 0.543951 m3
Données d'identification - Identifiant: 56
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 38 VL IS Tri, BIM_EXTH_ECOWATT_04à38_PM_VL:EXTH ECOWATT PM 38 VL IS Tri:293720
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.44 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_VL
Type - Cotes(Type) - A: 1.106 m; B: 0.923 m; C: 0.666 m; E: 1.022 m; F: 0.894 m; G: 0.315 m; H: 0.323 m; Hauteur_porte: 0.562 m; I: 0.27 m; J: 0.345 m; Largeur_porte: 0.648 m; ØD1: 0.5 m; ØD1_Int: 0.496 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 263020; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 38 VL IS Tri RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 38 VL IS Tri; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 88 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 1.3 A; Nombre_de_phases: 3; Protection_IP: IP54; Puissance_electrique: 700 W; Tension_nominale: 37.1612 V
Type - Génie climatique(Type) - Debit_maxi: 4200 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 38 VL IS Tri; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 38 VL IS Tri; ID du type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 38 VL IS Tri; Type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 38 VL IS Tri
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 3.55384 m2; Volume: 0.543951 m3
Données d'identification - Identifiant: 57
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 38 VL NU, BIM_EXTH_ECOWATT_04à38_PM_VL:EXTH ECOWATT PM 38 VL NU:293732
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.44 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_VL
Type - Cotes(Type) - A: 1.106 m; B: 0.923 m; C: 0.639 m; E: 1.022 m; F: 0.894 m; G: 0.315 m; H: 0.323 m; Hauteur_porte: 0.562 m; I: 0.27 m; J: 0.345 m; Largeur_porte: 0.648 m; ØD1: 0.5 m; ØD1_Int: 0.496 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 263020; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 38 VL Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 38 VL NU; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 78 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 3.1 A; Nombre_de_phases: 1; Protection_IP: IP54; Puissance_electrique: 700 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 4200 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 38 VL NU; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 38 VL NU; ID du type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 38 VL NU; Type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 38 VL NU
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 3.50279 m2; Volume: 0.519948 m3
Données d'identification - Identifiant: 58
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 38 VL NU Tri, BIM_EXTH_ECOWATT_04à38_PM_VL:EXTH ECOWATT PM 38 VL NU Tri:293744
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.44 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_VL
Type - Cotes(Type) - A: 1.106 m; B: 0.923 m; C: 0.639 m; E: 1.022 m; F: 0.894 m; G: 0.315 m; H: 0.323 m; Hauteur_porte: 0.562 m; I: 0.27 m; J: 0.345 m; Largeur_porte: 0.648 m; ØD1: 0.5 m; ØD1_Int: 0.496 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 263020; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 38 VL Tri RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 38 VL NU Tri; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 78 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 1.3 A; Nombre_de_phases: 3; Protection_IP: IP54; Puissance_electrique: 700 W; Tension_nominale: 37.1612 V
Type - Génie climatique(Type) - Debit_maxi: 4200 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 38 VL NU Tri; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 38 VL NU Tri; ID du type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 38 VL NU Tri; Type: BIM_EXTH_ECOWATT_04à38_PM_VL: EXTH ECOWATT PM 38 VL NU Tri
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 3.50279 m2; Volume: 0.519948 m3
Données d'identification - Identifiant: 59
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction
