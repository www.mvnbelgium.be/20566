Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2021-04-15T09:27:20
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Interface alternative d'export 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Apr 15 09:27:20 2021 * Host: User-PC * Database: C:\Users\User\AppData\Local\Temp\{81142884-2CA5-4AD4-9993-954CFC179E50}\ifc * Database version: 5507 * Database creation date: Thu Apr 15 09:27:18 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Apr 15 09:27:18 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Apr 15 09:27:18 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 52, 0, 117187; RefLongitude: 2, 19, 59, 880409; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no

# IfcFlowMovingDevice: EXTH ECOWATT PM 04 HL IS, BIM_EXTH_ECOWATT_04à38_PM_HL:EXTH ECOWATT PM 04 HL IS:291980
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HL; Visibilité_marque: yes
Type - Cotes(Type) - A: 0.627 m; B: 0.523 m; C: 0.347 m; E: 0.568 m; F: 0.502 m; G: 0.157 m; H: 0.175 m; Hauteur_porte: 0.255 m; I: 0.157 m; J: 0.161 m; Largeur_porte: 0.439 m; ØD1: 0.16 m; ØD1_Int: 0.156 m; Pos_H_inter: 0.413 m; Pos_V_inter: 0.097 m
Type - Données d'identification(Type) - Code_article: 5400200; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 04 HL IS Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 04 HL IS; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 24 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 0.7 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 70 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 480 m³/h; Debit_mini: 20 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 04 HL IS; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 04 HL IS; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 04 HL IS; Type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 04 HL IS
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0
Cotes - Surface: 1.08772 m2; Volume: 0.0793853 m3
Données d'identification - Identifiant: 44
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 04 HL NU, BIM_EXTH_ECOWATT_04à38_PM_HL:EXTH ECOWATT PM 04 HL NU:291992
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HL
Type - Cotes(Type) - A: 0.627 m; B: 0.523 m; C: 0.32 m; E: 0.568 m; F: 0.502 m; G: 0.157 m; H: 0.175 m; Hauteur_porte: 0.255 m; I: 0.157 m; J: 0.161 m; Largeur_porte: 0.439 m; ØD1: 0.16 m; ØD1_Int: 0.156 m; Pos_H_inter: 0.413 m; Pos_V_inter: 0.097 m
Type - Données d'identification(Type) - Code_article: 5400201; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 04 HL Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 04 HL NU; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 21 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 0.7 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 70 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 480 m³/h; Debit_mini: 20 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 04 HL NU; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 04 HL NU; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 04 HL NU; Type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 04 HL NU
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.0604 m2; Volume: 0.0724983 m3
Données d'identification - Identifiant: 45
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 06 HL IS, BIM_EXTH_ECOWATT_04à38_PM_HL:EXTH ECOWATT PM 06 HL IS:292004
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HL
Type - Cotes(Type) - A: 0.627 m; B: 0.523 m; C: 0.347 m; E: 0.568 m; F: 0.502 m; G: 0.157 m; H: 0.175 m; Hauteur_porte: 0.255 m; I: 0.157 m; J: 0.161 m; Largeur_porte: 0.439 m; ØD1: 0.2 m; ØD1_Int: 0.196 m; Pos_H_inter: 0.413 m; Pos_V_inter: 0.097 m
Type - Données d'identification(Type) - Code_article: 5400208; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 06 HL IS Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 06 HL IS; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 24 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 130 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 660 m³/h; Debit_mini: 70 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 06 HL IS; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 06 HL IS; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 06 HL IS; Type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 06 HL IS
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.09954 m2; Volume: 0.079408 m3
Données d'identification - Identifiant: 46
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 06 HL NU, BIM_EXTH_ECOWATT_04à38_PM_HL:EXTH ECOWATT PM 06 HL NU:292016
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HL
Type - Cotes(Type) - A: 0.627 m; B: 0.523 m; C: 0.32 m; E: 0.568 m; F: 0.502 m; G: 0.157 m; H: 0.175 m; Hauteur_porte: 0.255 m; I: 0.157 m; J: 0.161 m; Largeur_porte: 0.439 m; ØD1: 0.2 m; ØD1_Int: 0.196 m; Pos_H_inter: 0.413 m; Pos_V_inter: 0.097 m
Type - Données d'identification(Type) - Code_article: 5400209; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 06 HL Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 06 HL NU; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 21 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 130 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 660 m³/h; Debit_mini: 70 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 06 HL NU; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 06 HL NU; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 06 HL NU; Type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 06 HL NU
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.07221 m2; Volume: 0.0725209 m3
Données d'identification - Identifiant: 47
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 10 HL IS, BIM_EXTH_ECOWATT_04à38_PM_HL:EXTH ECOWATT PM 10 HL IS:292028
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HL
Type - Cotes(Type) - A: 0.627 m; B: 0.566 m; C: 0.448 m; E: 0.569 m; F: 0.544 m; G: 0.207 m; H: 0.185 m; Hauteur_porte: 0.355 m; I: 0.207 m; J: 0.186 m; Largeur_porte: 0.245 m; ØD1: 0.25 m; ØD1_Int: 0.246 m; Pos_H_inter: 0.192 m; Pos_V_inter: 0.095 m
Type - Données d'identification(Type) - Code_article: 5400218; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 10 HL IS Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 10 HL IS; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 30 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1.2 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 150 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 1150 m³/h; Debit_mini: 100 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 10 HL IS; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 10 HL IS; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 10 HL IS; Type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 10 HL IS
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.25605 m2; Volume: 0.115025 m3
Données d'identification - Identifiant: 48
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 10 HL NU, BIM_EXTH_ECOWATT_04à38_PM_HL:EXTH ECOWATT PM 10 HL NU:292040
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HL
Type - Cotes(Type) - A: 0.627 m; B: 0.566 m; C: 0.421 m; E: 0.569 m; F: 0.544 m; G: 0.207 m; H: 0.185 m; Hauteur_porte: 0.355 m; I: 0.207 m; J: 0.186 m; Largeur_porte: 0.245 m; ØD1: 0.25 m; ØD1_Int: 0.246 m; Pos_H_inter: 0.192 m; Pos_V_inter: 0.095 m
Type - Données d'identification(Type) - Code_article: 5400219; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 10 HL Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 10 HL NU; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 26 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1.2 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 150 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 1150 m³/h; Debit_mini: 100 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 10 HL NU; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 10 HL NU; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 10 HL NU; Type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 10 HL NU
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.22756 m2; Volume: 0.107515 m3
Données d'identification - Identifiant: 49
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 22 HL IS, BIM_EXTH_ECOWATT_04à38_PM_HL:EXTH ECOWATT PM 22 HL IS:292052
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HL
Type - Cotes(Type) - A: 0.767 m; B: 0.683 m; C: 0.538 m; E: 0.709 m; F: 0.661 m; G: 0.252 m; H: 0.237 m; Hauteur_porte: 0.43 m; I: 0.252 m; J: 0.239 m; Largeur_porte: 0.245 m; ØD1: 0.355 m; ØD1_Int: 0.351 m; Pos_H_inter: 0.192 m; Pos_V_inter: 0.115 m
Type - Données d'identification(Type) - Code_article: 5400230; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 22 HL IS Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 22 HL IS; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 45 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1.6 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 350 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 2200 m³/h; Debit_mini: 100 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 22 HL IS; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 22 HL IS; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 22 HL IS; Type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 22 HL IS
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0
Cotes - Surface: 1.84859 m2; Volume: 0.216608 m3
Données d'identification - Identifiant: 50
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 22 HL NU, BIM_EXTH_ECOWATT_04à38_PM_HL:EXTH ECOWATT PM 22 HL NU:292064
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HL
Type - Cotes(Type) - A: 0.767 m; B: 0.683 m; C: 0.511 m; E: 0.709 m; F: 0.661 m; G: 0.252 m; H: 0.237 m; Hauteur_porte: 0.43 m; I: 0.252 m; J: 0.239 m; Largeur_porte: 0.245 m; ØD1: 0.355 m; ØD1_Int: 0.351 m; Pos_H_inter: 0.192 m; Pos_V_inter: 0.115 m
Type - Données d'identification(Type) - Code_article: 5400231; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 22 HL Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 22 HL NU; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 38 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1.6 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 350 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 2200 m³/h; Debit_mini: 100 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 22 HL NU; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 22 HL NU; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 22 HL NU; Type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 22 HL NU
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.81317 m2; Volume: 0.205001 m3
Données d'identification - Identifiant: 51
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 30 HL IS, BIM_EXTH_ECOWATT_04à38_PM_HL:EXTH ECOWATT PM 30 HL IS:292076
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HL
Type - Cotes(Type) - A: 1.018 m; B: 0.824 m; C: 0.6 m; E: 0.89 m; F: 0.796 m; G: 0.28 m; H: 0.273 m; Hauteur_porte: 0.497 m; I: 0.28 m; J: 0.273 m; Largeur_porte: 0.648 m; ØD1: 0.4 m; ØD1_Int: 0.396 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410240; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 30 HL IS Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 30 HL IS; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 73 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 2.6 A; Nombre_de_phases: 1; Protection_IP: IP54; Puissance_electrique: 600 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 3200 m³/h; Debit_mini: 200 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 30 HL IS; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 30 HL IS; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 30 HL IS; Type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 30 HL IS
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 2.9898 m2; Volume: 0.405904 m3
Données d'identification - Identifiant: 52
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 30 HL IS Tri, BIM_EXTH_ECOWATT_04à38_PM_HL:EXTH ECOWATT PM 30 HL IS Tri:292088
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HL
Type - Cotes(Type) - A: 1.018 m; B: 0.824 m; C: 0.6 m; E: 0.89 m; F: 0.796 m; G: 0.28 m; H: 0.273 m; Hauteur_porte: 0.497 m; I: 0.28 m; J: 0.273 m; Largeur_porte: 0.648 m; ØD1: 0.4 m; ØD1_Int: 0.396 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5420240; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 30 HL IS Tri RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 30 HL IS Tri; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 73 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 1.2 A; Nombre_de_phases: 3; Protection_IP: IP54; Puissance_electrique: 600 W; Tension_nominale: 37.1612 V
Type - Génie climatique(Type) - Debit_maxi: 3200 m³/h; Debit_mini: 200 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 30 HL IS Tri; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 30 HL IS Tri; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 30 HL IS Tri; Type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 30 HL IS Tri
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 2.9898 m2; Volume: 0.405904 m3
Données d'identification - Identifiant: 53
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 30 HL NU, BIM_EXTH_ECOWATT_04à38_PM_HL:EXTH ECOWATT PM 30 HL NU:292100
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HL
Type - Cotes(Type) - A: 1.018 m; B: 0.824 m; C: 0.574 m; E: 0.89 m; F: 0.796 m; G: 0.28 m; H: 0.273 m; Hauteur_porte: 0.497 m; I: 0.28 m; J: 0.273 m; Largeur_porte: 0.648 m; ØD1: 0.4 m; ØD1_Int: 0.396 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410241; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 30 HL Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 30 HL NU; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 64 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 2.6 A; Nombre_de_phases: 1; Protection_IP: IP54; Puissance_electrique: 600 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 3200 m³/h; Debit_mini: 200 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 30 HL NU; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 30 HL NU; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 30 HL NU; Type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 30 HL NU
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 2.9455 m2; Volume: 0.387181 m3
Données d'identification - Identifiant: 54
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 30 HL NU Tri, BIM_EXTH_ECOWATT_04à38_PM_HL:EXTH ECOWATT PM 30 HL NU Tri:292112
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HL
Type - Cotes(Type) - A: 1.018 m; B: 0.824 m; C: 0.574 m; E: 0.89 m; F: 0.796 m; G: 0.28 m; H: 0.273 m; Hauteur_porte: 0.497 m; I: 0.28 m; J: 0.273 m; Largeur_porte: 0.648 m; ØD1: 0.4 m; ØD1_Int: 0.396 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410242; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 30 HL Tri RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 30 HL NU Tri; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 64 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 1.2 A; Nombre_de_phases: 3; Protection_IP: IP54; Puissance_electrique: 600 W; Tension_nominale: 37.1612 V
Type - Génie climatique(Type) - Debit_maxi: 3200 m³/h; Debit_mini: 200 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 30 HL NU Tri; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 30 HL NU Tri; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 30 HL NU Tri; Type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 30 HL NU Tri
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 2.9455 m2; Volume: 0.387181 m3
Données d'identification - Identifiant: 55
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 38 HL IS, BIM_EXTH_ECOWATT_04à38_PM_HL:EXTH ECOWATT PM 38 HL IS:292124
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HL
Type - Cotes(Type) - A: 1.152 m; B: 0.923 m; C: 0.666 m; E: 1.022 m; F: 0.894 m; G: 0.315 m; H: 0.323 m; Hauteur_porte: 0.562 m; I: 0.315 m; J: 0.323 m; Largeur_porte: 0.648 m; ØD1: 0.5 m; ØD1_Int: 0.496 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410259; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 38 HL IS Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 38 HL IS; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 88 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 3.1 A; Nombre_de_phases: 1; Protection_IP: IP54; Puissance_electrique: 700 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 4200 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 38 HL IS; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 38 HL IS; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 38 HL IS; Type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 38 HL IS
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 3.75322 m2; Volume: 0.585507 m3
Données d'identification - Identifiant: 56
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 38 HL IS Tri, BIM_EXTH_ECOWATT_04à38_PM_HL:EXTH ECOWATT PM 38 HL IS Tri:292136
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HL
Type - Cotes(Type) - A: 1.152 m; B: 0.923 m; C: 0.666 m; E: 1.022 m; F: 0.894 m; G: 0.315 m; H: 0.323 m; Hauteur_porte: 0.562 m; I: 0.315 m; J: 0.323 m; Largeur_porte: 0.648 m; ØD1: 0.5 m; ØD1_Int: 0.496 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5420259; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 38 HL IS Tri RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 38 HL IS Tri; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 88 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 1.3 A; Nombre_de_phases: 3; Protection_IP: IP54; Puissance_electrique: 700 W; Tension_nominale: 37.1612 V
Type - Génie climatique(Type) - Debit_maxi: 4200 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 38 HL IS Tri; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 38 HL IS Tri; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 38 HL IS Tri; Type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 38 HL IS Tri
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 3.75322 m2; Volume: 0.585507 m3
Données d'identification - Identifiant: 57
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 38 HL NU, BIM_EXTH_ECOWATT_04à38_PM_HL:EXTH ECOWATT PM 38 HL NU:292148
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HL
Type - Cotes(Type) - A: 1.152 m; B: 0.923 m; C: 0.639 m; E: 1.022 m; F: 0.894 m; G: 0.315 m; H: 0.323 m; Hauteur_porte: 0.562 m; I: 0.315 m; J: 0.323 m; Largeur_porte: 0.648 m; ØD1: 0.5 m; ØD1_Int: 0.496 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410260; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 38 HL Mono RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 38 HL NU; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 78 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 3.1 A; Nombre_de_phases: 1; Protection_IP: IP54; Puissance_electrique: 700 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 4200 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 38 HL NU; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 38 HL NU; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 38 HL NU; Type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 38 HL NU
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 3.70092 m2; Volume: 0.560417 m3
Données d'identification - Identifiant: 58
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PM 38 HL NU Tri, BIM_EXTH_ECOWATT_04à38_PM_HL:EXTH ECOWATT PM 38 HL NU Tri:292160
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PM_HL
Type - Cotes(Type) - A: 1.152 m; B: 0.923 m; C: 0.639 m; E: 1.022 m; F: 0.894 m; G: 0.315 m; H: 0.323 m; Hauteur_porte: 0.562 m; I: 0.315 m; J: 0.323 m; Largeur_porte: 0.648 m; ØD1: 0.5 m; ØD1_Int: 0.496 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410261; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/20_exth-ecowatt-pm_012020.pdf; Modèle: EXTH ECOWATT PM 38 HL Tri RMEC Caisson C4 PM; Nom du type: EXTH ECOWATT PM 38 HL NU Tri; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 78 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 1.3 A; Nombre_de_phases: 3; Protection_IP: IP54; Puissance_electrique: 700 W; Tension_nominale: 37.1612 V
Type - Génie climatique(Type) - Debit_maxi: 4200 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 38 HL NU Tri; Famille et type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 38 HL NU Tri; ID du type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 38 HL NU Tri; Type: BIM_EXTH_ECOWATT_04à38_PM_HL: EXTH ECOWATT PM 38 HL NU Tri
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 3.70092 m2; Volume: 0.560417 m3
Données d'identification - Identifiant: 59
Génie climatique - Classification du système: Reprise,Extraction d'air,Puissance; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction
